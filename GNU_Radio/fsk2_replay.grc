options:
  parameters:
    author: '00'
    generate_options: qt_gui
    id: fsk2_replay
    output_language: python
    title: Captured 2FSK replay
  states: {}

blocks:
- name: display_decim
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: power_avg_samples
  id: variable
  parameters:
    value: int(samp_rate*0.002)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\workspace\preparation\dinov3_11\data\2FSK\2FSK_0001.cf32
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: display_decim
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: power_avg_samples
    max_iter: '4000'
    scale: 1.0/power_avg_samples
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0
    name: '"CW - Spectrum"'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0
    name: '"CW - I and Q"'
    size: '200'
    srate: samp_rate
    type: complex
    ymax: '0.12'
    ymin: '-0.12'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,0
    name: '"Recorded IQ power"'
    size: '2000'
    srate: samp_rate/display_decim
    type: float
    ymax: '0.003'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    gui_hint: 2,0
    int_max: '-20'
    int_min: '-100'
    name: '"CW - Waterfall"'
    type: complex
    wintype: window.WIN_HANN
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_moving_average_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
